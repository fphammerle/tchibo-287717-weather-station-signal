options:
  parameters:
    generate_options: qt_gui
    id: record
    output_language: python
    title: Record 287717 Weather Station Signal
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {}
- name: frequency_hertz
  id: variable
  parameters:
    value: '433790000'
  states: {}
- name: iq_output_filename
  id: variable
  parameters:
    value: datetime.datetime.now().astimezone().strftime("%Y%m%dT%H%M%S%z") + "_{}Hz.cf32".format(sample_rate_hertz)
  states: {}
- name: sample_rate_hertz
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: wav_output_filename
  id: variable
  parameters:
    value: datetime.datetime.now().astimezone().strftime("%Y%m%dT%H%M%S%z") + "_magnitude-squared_pcm_16bit.wav"
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-45'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output_filename
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: recordings/20201222T114639+0100_1800000Hz.cf32
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: wav_output_filename
    samp_rate: int(sample_rate_hertz / decimation)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: decimation
    gain: '10'
    samp_rate: sample_rate_hertz
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    legend: 'False'
    size: int(sample_rate_hertz / decimation)
    srate: sample_rate_hertz / decimation
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate_hertz
    fc: frequency_hertz
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate_hertz
    fc: '0'
    fftsize: '1024'
    name: '"low pass"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency_hertz
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: sample_rate_hertz
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_file_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
